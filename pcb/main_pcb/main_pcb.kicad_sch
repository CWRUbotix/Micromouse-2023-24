File: pcb/main_pcb/main_pcb.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: changes to pcb
Other:
- removed sheet microcontroller1
